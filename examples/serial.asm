ORG 2000H
MAIN:
    CALL SERIAL_INIT
    CALL RECEIVECHAR
    CALL SENDCHAR

    
SERIAL_INIT:
    MOV SCON, #52H
    MOV TMOD, #20H
    MOV A, PCON
    SETB ACC.7
    MOV PCON, A

    MOV TH1, #-3
    SETB TR1
RET

SENDCHAR:
    JNB TI, $
    CLR TI
    MOV SBUF, A
RET

RECEIVECHAR:
    JNB RI, $
    CLR RI
    MOV A, SBUF
RET
END