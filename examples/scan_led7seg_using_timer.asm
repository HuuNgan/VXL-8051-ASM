ORG 0000H
JMP MAIN
ORG 000BH
JMP TIM0_ISR
ORG 0030H
MAIN:
    MOV IE, #82H
    MOV TMOD, #01H 
    SETB TF0

    MOV R0, #20H
    MOV 20H, #2
    MOV 21H, #3
    MOV 22H, #4
    MOV 23H, #5
    SJMP $

TIM0_ISR:
    CLR TR0
    MOV TH0, #HIGH(-1000)
    MOV TL0, #LOW(-1000)
    SETB TR0

    CPL P1.0

    MOV A, R0
    ADD A, #-20H
    MOV DPTR, #LED_LOC
    MOVC A, @A+DPTR
    ADD A, @R0    
    MOV DPTR, #0000H
    MOVX @DPTR, A
    INC R0 
    CJNE R0, #24H, SKIP
    MOV R0, #20H
SKIP:
RETI

LED_LOC:
    DB 01110000B, 10110000B, 11010000B, 11100000B
END