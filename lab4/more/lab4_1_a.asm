	ORG		2000H
	COUNT	EQU		-50000
	MOV		TMOD,#01H
	SETB	P1.5
MAIN:
	JB		P1.1,$
	CPL		P1.5
	ACALL	DELAY_200m
	JB		P1.1,MAIN
	JNB 	P1.1, $
		
	SJMP	MAIN

DELAY_5u:
	MOV		TH0,#HIGH(COUNT)
	MOV		TL0,#LOW(COUNT)
	SETB	TR0
	JNB		TF0,$
	CLR		TR0
	CLR		TF0
RET

DELAY_200m:
	MOV		R7,#4
LOOP:
	ACALL	DELAY_5u
	DJNZ	R7,LOOP
	RET
END
;CODE TH3 LUU NHAM